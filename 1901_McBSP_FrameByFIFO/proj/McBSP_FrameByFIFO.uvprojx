# Keil uVision project McBSP_FrameByFIFO.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: McBSP_FrameByFIFO
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\lib;..\src
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group user
    ../src/: main.c McBSP.c
  group startup
    ../lib/: startup_MDR1901VC1T.s system_MDR1901VC1T.c system_MDR1901VC1T.h
  group driver
    ../lib/: MDR32F9Qx_port.c MDR32F9Qx_rst_clk.c
